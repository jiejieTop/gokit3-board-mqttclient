# Keil uVision project gokit.uvprojx, settings and files
target gokit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gokit +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../stm32_hal_drivers/STM32F1xx_HAL_Driver/Inc;../stm32_hal_drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../stm32_hal_drivers/CMSIS/Include;../stm32_hal_drivers/CMSIS/Device/ST/STM32F1xx/Include;..\user;..\bsp;..\bsp\led;..\bsp\dwt;..\bsp\usart;..\bsp\motor;..\bsp\dht11;..\tos\arch\arm\arm-v7m\common\include;..\tos\arch\arm\arm-v7m\cortex-m3\armcc;..\tos\kernel\core\include;..\tos\config;..\tos\kernel\pm\include;..\tos\at;..\tos\at\include;..\tos\at\esp8266;..\tos\at\sal_module_wrapper;..\mqttclient\common;..\mqttclient\common\log;..\mqttclient\mqtt;..\mqttclient\mqttclient;..\mqttclient\network;..\mqttclient\platform\TencentOS-tiny
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group stm32_hal_driver
    ../stm32_hal_drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c
  group startup
    ./: startup_stm32f103xb.s
  group cmsis
    ../stm32_hal_drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group user
    ../user/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group bsp
    ../bsp/dht11/: bsp_dht11.c
    ../bsp/dwt/: bsp_dwt.c
    ../bsp/led/: bsp_led.c
    ../bsp/usart/: bsp_usart.c
    ../bsp/: bsp_init.c
    ../bsp/motor/: bsp_motor.c
  group tos/at
    ../tos/at/: tos_hal_uart.c
    ../tos/at/src/: tos_at.c tos_at_utils.c
    ../tos/at/sal_module_wrapper/: sal_module_wrapper.c
    ../tos/at/esp8266/: esp8266.c
  group tos/kernel
    ../tos/kernel/core/: tos_binary_heap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_event.c tos_global.c tos_mail_queue.c tos_message_queue.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
  group tos/arch
    ../tos/arch/arm/arm-v7m/cortex-m3/armcc/: port_s.S port_c.c
    ../tos/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
  group tos/config
    ../tos/config/: tos_config.h
  group mqttclient
    ../mqttclient/mqttclient/: mqtt_config.h mqttclient.c mqttclient.h
  group mqttclient/mqtt
    ../mqttclient/mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group mqttclient/commont
    ../mqttclient/common/: list.c random.c log.h error.h
    ../mqttclient/common/log/: fifo.c format.c salof.c
    ../mqttclient/common/log/arch/tencentos-tiny/: arch.c
  group mqttclient/network
    ../mqttclient/network/: network.c
  group mqttclient/platform
    ../mqttclient/platform/TencentOS-tiny/: platform_memory.c platform_mutex.c platform_net_socket.c platform_nettype_tcp.c platform_nettype_tls.c platform_thread.c platform_timer.c
